COMPATIBLE_MACHINE  = "^(phyboard-hon)$"